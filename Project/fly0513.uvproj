# Keil uVision project fly0513.uvproj, settings and files
target Fly0513 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fly0513 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: ..\BSP;..\CMSIS;..\Lib\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h RC.c Control.c IMU.c Data_Transfer.c
  group BSP
    ../BSP/: Tim3.c USART1.c SPI1.c Led.c Motor.c Time.c Tim_PWM_In.c NRF24L.c ADC.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c
